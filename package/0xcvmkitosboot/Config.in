## package/0xcvmkitosboot/Config.in
```kconfig
config BR2_PACKAGE_0xcvmkitosboot
    bool "0xcvmkitosboot"
    help
        XCVMKitOSBootLoader
```
